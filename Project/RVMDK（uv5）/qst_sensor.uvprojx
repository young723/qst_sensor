# Keil uVision project qst_sensor.uvprojx, settings and files
target qst_sensor (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qst_sensor +hex
  AfterMake: $KARM\ARMCC\bin\fromelf --bin --output="$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER USE_I2C_1_PB8_9 QST_USE_SW_I2C
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\i2c;..\..\User\spi;..\..\User\usart;..\..\User\qmaX981
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/usart/: bsp_usart.c
    ../../User/i2c/: bsp_i2c.c qst_sw_i2c.c
    ../../User/rtc/: bsp_rtc.c bsp_date.c bsp_calendar.c
    ../../User/qmaX981/: qmaX981.c qmaX981_algo.c
    ../../User/qmcX983/: qmcX983.c
    ../../User/spi/: bsp_spi.c
    ../../User/qmp6988/: qmp6988.c
    ../../User/fis210x/: fis210x.c
    ../../User/jhm1200/: api_711_internal.c virtual_iic.c
    ../../User/qmc6308/: qmc6308.c
  group DOC
    ../../Doc/: readme.txt
  group algo
    ../../algo/imu/: FastMath.cpp imualgo.cpp
    ../../algo/compass/: ical.c
  group upper
    ../../upper/: qst_packet.c
